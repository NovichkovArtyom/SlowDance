# Keil uVision project SlowDance.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F072CBTx STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x00004000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: SlowDance
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\keil;.\src;.\Listings;.\Objects;.\RTE\Device\STM32F072CBTx;.\RTE\_Target_1
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group src
    ./src/: target.cpp pwm.cpp mcu.cpp main.cpp adc.cpp
software components: CMSIS:CORE 5.3.0, CMSIS:DSP 1.7.0, Device:Startup 1.0.0
